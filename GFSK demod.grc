<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>GFSK_Demod</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>36e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_cutoff</value></param>
<param><key>value</key><value>38e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_transition_width</value></param>
<param><key>value</key><value>19000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rat_decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rat_interop</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>((samp_rate/2/firdes_decim)*rat_interop/rat_decim)/symbole_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbole_rate</value></param>
<param><key>value</key><value>2400</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*deviation/8.0)</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0</value></param>
<param><key>omega_relative_limit</key><value>0</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
